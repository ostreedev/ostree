require NetworkManager.inc

SRC_URI[md5sum] = "9013a046e49a9d7e384a94290f40f28a"
SRC_URI[sha256sum] = "332cdd94f480099d23f39d56b3aee9925e435ffe91d088a9476d9b8b3586887a"
